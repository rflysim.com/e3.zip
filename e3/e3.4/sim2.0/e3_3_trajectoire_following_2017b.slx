simulink model "e3_3_trajectoire_following_2017b"  (R2017b)
settings: Solver=FixedStepAuto  StartTime=0.0  StopTime=100  FixedStep=1/120  RelTol=1e-3  EnableMultiTasking=on
values from neighbouring files (symbols this model uses):
  a = XMAX    (= 0.8)    [start_tello.m]
  b = YMAX    (= 1.2)    [start_tello.m]
  battery_threshold = 15    [start_tello.m]
  bb = (ZMIN*YMAX - ZMAX*YMIN)/(YMAX - YMIN)    (= -1.05)    [start_tello.m]
  k = (ZMAX - ZMIN)/(YMAX - YMIN)    (= 0.458333333333)    [start_tello.m]
  omega = 0.3    [start_tello.m]
  R = 1    [start_tello.m]
  sim_end_time = 15*act_end + 4    (= 475.238898038)    [start_tello.m]
  tb2 = tb    (= 2.7)    [start_tello.m]
  tb3 = tb*2    (= 5.4)    [start_tello.m]
  tb4 = tb*3    (= 8.1)    [start_tello.m]
  tb5 = tb*4    (= 10.8)    [start_tello.m]
  tb6 = tb*5    (= 13.5)    [start_tello.m]
  tb7 = tb*6    (= 16.2)    [start_tello.m]
  tb8 = tb*7    (= 18.9)    [start_tello.m]
  TELLO1_NUM = uint8(1)    [start_tello.m]
  TELLO2_NUM = uint8(2)    [start_tello.m]
  TELLO3_NUM = uint8(3)    [start_tello.m]
  TELLO4_NUM = uint8(4)    [start_tello.m]
  TELLO5_NUM = uint8(5)    [start_tello.m]
  TELLO6_NUM = uint8(6)    [start_tello.m]
  TELLO7_NUM = uint8(7)    [start_tello.m]
  TELLO8_NUM = uint8(8)    [start_tello.m]
  UAV_NUM = 0    [start_tello.m]
  w1 = 0.4    [start_tello.m]
  w2 = 0.2    [start_tello.m]
  z_d_for_land = -0.2    [start_tello.m]
libraries: simulink x51, etargetslib x24, dspnetwork x24, sharedtransform x8, aerolibanimutils x1
(part 4 of 4)

== matlab function e3_3_trajectoire_following_2017b/control system/Kalman_Filtre/Kalman Filtre H/Kalman Filtre H/Kalman Filtre for getting the velocity H ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var = 0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];

% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e3_3_trajectoire_following_2017b/control system/Kalman_Filtre/Kalman Filtre H/Kalman Filtre for getting the velocity H ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity) % Mesurement_State

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[[0.1,0 0;0,0.1,0;0 0 0.1] zeros(3) zeros(3) ;zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1] zeros(3);zeros(3) zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1]]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0;0;0;0;0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.025;

% Process Noise
p_var =3; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise
Q_delay=[Q zeros(3) zeros(3);zeros(3) Q zeros(3);zeros(3) zeros(3) Q];
% Mesurement Noise
m_var = 0.05; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise
R_delay=R;
V_delay=R_delay*randn;
% Observation matrice
H=[1 0 0];
H_delay=[0 0 0 0 0 0 H];
% The indentity matrice
I=eye(3); 
I_delay=eye(9);

A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];
A_delay=[A zeros(3) zeros(3);zeros(3) A zeros(3); zeros(3) zeros(3) A];
% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% X_real_static=X_real;    
% Mesurement_Velocity=H_delay*(Mesurement_State)+V_delay;

%   Kalman Update process
    X_pre=A_delay*Xkf_static; % State estimation
    P_pre=A_delay*P0_static*A_delay'+Q_delay; % Covariance matrice estimation

    Kg=P_pre*H_delay'*inv(H_delay*P_pre*H_delay'+R_delay); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H_delay*X_pre); % State estimation update
    Covariance_matrice=(I_delay-Kg*H_delay)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e3_3_trajectoire_following_2017b/control system/Kalman_Filtre/Kalman Filtre Psi/Kalman Filtre Psi/Kalman Filtre for getting the velocity Psi ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.01; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var = 0.05; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];


% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e3_3_trajectoire_following_2017b/control system/Kalman_Filtre/Kalman Filtre Psi/Kalman Filtre for getting the velocity Psi ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity) % Mesurement_State

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[[0.1,0 0;0,0.1,0;0 0 0.1] zeros(3) zeros(3) ;zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1] zeros(3);zeros(3) zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1]]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0;0;0;0;0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise
Q_delay=[Q zeros(3) zeros(3);zeros(3) Q zeros(3);zeros(3) zeros(3) Q];
% Mesurement Noise
m_var = 0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise
R_delay=R;
V_delay=R_delay*randn;
% Observation matrice
H=[1 0 0];
H_delay=[0 0 0 0 0 0 H];
% The indentity matrice
I=eye(3); 
I_delay=eye(9);

A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];
A_delay=[A zeros(3) zeros(3);zeros(3) A zeros(3); zeros(3) zeros(3) A];
% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% X_real_static=X_real;    
% Mesurement_Velocity=H_delay*(Mesurement_State)+V_delay;

%   Kalman Update process
    X_pre=A_delay*Xkf_static; % State estimation
    P_pre=A_delay*P0_static*A_delay'+Q_delay; % Covariance matrice estimation

    Kg=P_pre*H_delay'*inv(H_delay*P_pre*H_delay'+R_delay); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H_delay*X_pre); % State estimation update
    Covariance_matrice=(I_delay-Kg*H_delay)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e3_3_trajectoire_following_2017b/control system/Kalman_Filtre/Kalman Filtre X/Kalman Filtre X/Kalman Filtre for getting the velocity X ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var = 0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];

% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller3/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller3/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller4/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller4/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller5/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller5/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller6/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller6/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller7/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller7/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller8/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e3_3_trajectoire_following_2017b/control system/Baseline Controller8/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e3_3_trajectoire_following_2017b/control system/Kalman_Filtre/Kalman Filtre X/Kalman Filtre for getting the velocity X ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity) % Mesurement_State

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[[0.1,0 0;0,0.1,0;0 0 0.1] zeros(3) zeros(3) ;zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1] zeros(3);zeros(3) zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1]]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0;0;0;0;0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.025;

% Process Noise
p_var =3; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise
Q_delay=[Q zeros(3) zeros(3);zeros(3) Q zeros(3);zeros(3) zeros(3) Q];
% Mesurement Noise
m_var =0.05; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise
R_delay=R;
V_delay=R_delay*randn;
% Observation matrice
H=[1 0 0];
H_delay=[0 0 0 0 0 0 H];
% The indentity matrice
I=eye(3); 
I_delay=eye(9);

A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];
A_delay=[A zeros(3) zeros(3);zeros(3) A zeros(3); zeros(3) zeros(3) A];
% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% X_real_static=X_real;    
% Mesurement_Velocity=H_delay*(Mesurement_State)+V_delay;

%   Kalman Update process
    X_pre=A_delay*Xkf_static; % State estimation
    P_pre=A_delay*P0_static*A_delay'+Q_delay; % Covariance matrice estimation

    Kg=P_pre*H_delay'*inv(H_delay*P_pre*H_delay'+R_delay); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H_delay*X_pre); % State estimation update
    Covariance_matrice=(I_delay-Kg*H_delay)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e3_3_trajectoire_following_2017b/control system/Kalman_Filtre/Kalman Filtre Y/Kalman Filtre Y/Kalman Filtre for getting the velocity Y ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var =0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];

% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e3_3_trajectoire_following_2017b/control system/Kalman_Filtre/Kalman Filtre Y/Kalman Filtre for getting the velocity Y ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity) % Mesurement_State

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
       P0_static=[[0.1,0 0;0,0.1,0;0 0 0.1] zeros(3) zeros(3) ;zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1] zeros(3);zeros(3) zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1]]; % the initilized matrice of estimated error 
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0;0;0;0;0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.025;

% Process Noise
p_var =3; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise
Q_delay=[Q zeros(3) zeros(3);zeros(3) Q zeros(3);zeros(3) zeros(3) Q];
% Mesurement Noise
m_var = 0.05; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise
R_delay=R;
V_delay=R_delay*randn;
% Observation matrice
H=[1 0 0];
H_delay=[0 0 0 0 0 0 H];
% The indentity matrice
I=eye(3); 
I_delay=eye(9);

A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];
A_delay=[A zeros(3) zeros(3);zeros(3) A zeros(3); zeros(3) zeros(3) A];
% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% X_real_static=X_real;    
% Mesurement_Velocity=H_delay*(Mesurement_State)+V_delay;

%   Kalman Update process
    X_pre=A_delay*Xkf_static; % State estimation
    P_pre=A_delay*P0_static*A_delay'+Q_delay; % Covariance matrice estimation

    Kg=P_pre*H_delay'*inv(H_delay*P_pre*H_delay'+R_delay); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H_delay*X_pre); % State estimation update
    Covariance_matrice=(I_delay-Kg*H_delay)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;
